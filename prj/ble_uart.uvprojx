# Keil uVision project ble_uart.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: ble_uart +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\app;..\core;..\drive;..\lib\inc;..\lib\blecomm
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Core
    ../core/: startup_GW32L.s system_GW32L.c
  group App
    ../app/: mian.c
  group Lib
    ../lib/src/: GW32L0xx_adc.c GW32L0xx_buzzer.c GW32L0xx_cmu.c GW32L0xx_crc.c GW32L0xx_des.c GW32L0xx_dma.c GW32L0xx_flash.c GW32L0xx_i2c.c GW32L0xx_lcd.c GW32L0xx_lvd.c GW32L0xx_misc.c GW32L0xx_pca.c GW32L0xx_pmu.c GW32L0xx_port.c GW32L0xx_ram.c GW32L0xx_rmu.c GW32L0xx_rng.c GW32L0xx_rtc.c GW32L0xx_spi.c GW32L0xx_systick.c GW32L0xx_timer.c GW32L0xx_uart.c GW32L0xx_vc.c GW32L0xx_wdt.c
  group Dev
    ../drive/: spi.c debug.c delay.c
  group Blecomm
    ../lib/blecomm/: blecomm_api.lib
software components: CMSIS:CORE 3.40.0
